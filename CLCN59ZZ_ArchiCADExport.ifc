Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T09:58:04
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionControlElement: Concept Oblong Flush Plate, CLCN59ZZ:Concept Oblong Flush Plate:3547
In: Level 1
Classification: C1030200 (Uniformat); Material: Chrome
Pset_ManufacturerTypeInformation - ModelReference: Concept Oblong Flush Plate; Manufacturer: American Standard; ProductionYear: 2021
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0433207 m2; Volume: 0.000555993 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: CLCN59ZZ: Concept Oblong Flush Plate; Family and Type: CLCN59ZZ: Concept Oblong Flush Plate; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: CLCN59ZZ: Concept Oblong Flush Plate; Type Id: CLCN59ZZ: Concept Oblong Flush Plate; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Pro & Commercial (70); ProductGroup: Cistern Plates (02); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Sanitary Systems (15)
Identity Data(Type) - Assembly Code: C1030200; Description: Concept Oblong Flush Plate; Keynote: N13; Manufacturer: American Standard; Model: Concept Oblong Flush Plate; OmniClass Number: 23.65.05.11.11; OmniClass Title: Water Supply Systems; Type Comments: CLCN59ZZ; Type Name: Concept Oblong Flush Plate; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/clcn59zz/document/object-user-guide; BIMObjectName: AmericanStandard_CisternPlates_Concept_(CLCN59ZZ); NBSDescription: Push plates; NBSNote: n/a; NBSObjectName: American Standard - Push plates; NBSOfficeMasterTag: n/a; NBSReference: 45-25-60/370
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_30_36_33_68; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/clcn59zz/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/clcn59zz/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/clcn59zz/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/clcn59zz/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/clcn59zz/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: CLCN59ZZ; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: CLCN59ZZ; ModelReference: Concept Oblong Flush Plate; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Concept Oblong Flush Plate; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
